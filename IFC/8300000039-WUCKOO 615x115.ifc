Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: ef1abd8d-475d-4342-8ca2-37da03605d72, NumberOfSaves: 33]
File name: Project Number
Time: 2024-01-19T09:44:02+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, InPort_1731756_1
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: NLRS_57_AIR_UN_duct-diffuser-wuck-supply_LT_sacs:615x115, NLRS_57_AIR_UN_duct-diffuser-wuck-supply_LT_sacs:615x115:1731756
In: Default
Type - Description: Grill for round duct, type WUCK (supply); PredefinedType: DIFFUSER; Material: NLRS_57_sendzimir verzinkt_gen_sacs
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_duct-diffuser-wuck-supply_LT_sacs
Type - Constraints - Default Elevation: 0 mm
Type - General - SACS_Article_Data: WUCK_Data
Type - Identity Data - Assembly Code: 57; Description: Grill for round duct, type WUCK (supply); Model: WUCK; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 13-04-2023; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.20.01; Type Name: 615x115; URL: https://solid-air.nl/producten/solid-air-wuck/
Type - Mechanical - Flow - Max Flow: 200 dm3/s; Min Flow: 100 dm3/s
Classification: 57 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 615x115; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_duct-diffuser-wuck-supply_LT_sacs; Family and Type: NLRS_57_AIR_UN_duct-diffuser-wuck-supply_LT_sacs: 615x115; Type: 615x115; Type Id: 1731497
Model Properties - Color Option (1-3): 0; Flow Option: Straight (standard); Flow Pattern (1-4): 0; Rotatie (-45 tot 45): 0 deg; SACS_Color_Ral: yes; SACS_Option_1: WUCK; SACS_Option_2: OO (No volume damper); SACS_Standard_Color: yes; Volume Damper: no
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.000254469 m2; Maximum diameter: Ø 900; Minimum diameter: Ø 300; NLRS_M_c01_breedte: 615 mm; NLRS_M_c01_diameter: 160 mm; NLRS_M_c01_hoogte: 115 mm; Volume: 0.000579502 m3
Identity Data - Mark: 7538; NLRS_C_description: Grill for round duct, type WUCK (supply); NLRS_C_materiaal_kleur: Sendzimir verzinkt (standard); NLRS_C_model: WUCKOO 615x115; SACS_Article_Code: 8300000039; SACS_Gross_Cost: 50; SACS_Price_Date: 01-02-2022
Materials and Finishes - SACS_Color: Sendzimir verzinkt (standard); SACS_Face_Color: NLRS_57_sendzimir verzinkt_gen_sacs; SACS_Material_VCD: Extruded Aluminium
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_dBA: 28; SACS_Max_Ploss: 15 Pa; SACS_Primairy_Air_Temperature: 16 C; SACS_Room_Temperature: 25 C; System Classification: Supply Air
Mechanical - Flow - Flow: 0 dm3/s; NLRS_M_c01_debiet: 0 dm3/s; SACS_Cooling_Capacity: 0 W; SACS_Heating_Capacity: 0 W; SACS_Lp_dBA: 0; SACS_Throw: 0 mm
Phasing - Phase Created: New Construction
Visibility - SACS_Arrows_and_Throw_Enabled: yes; SACS_Throw_Visible: yes; SACS_Warning_Disable: yes
